# Keil uVision project GOWATCH.uvprojx, settings and files
target GOWATCH (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GOWATCH +hex
  c flags: Optim=3 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\led;..\SYSTEM\nvic;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\LIBRARY\inc;..\CORE;..\HARDWARE\adc;..\HARDWARE\ds3231;..\HARDWARE\i2c_soft;..\HARDWARE\bme280;..\HARDWARE\oled;..\HARDWARE\beep;..\HARDWARE;..\HARDWARE\mpu;..\HARDWARE\mpu\empl;..\APP;..\APP\games;..\APP\games\gamelife;..\HARDWARE\flash;..\HARDWARE\led
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c
  group LIBRARY
    ../LIBRARY/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_flash.c
  group HARDWARE
    ../HARDWARE/beep/: beep.c
    ../HARDWARE/i2c_soft/: i2c_soft.c
    ../HARDWARE/adc/: adc.c
    ../HARDWARE/ds3231/: ds3231.c
    ../HARDWARE/bme280/: bme280.c
    ../HARDWARE/oled/: oled.c oled_driver.c
    ../HARDWARE/flash/: stmflash.c
    ../HARDWARE/led/: led.c
  group MPU6050
    ../HARDWARE/mpu/: mpu_task.c mpu6050.c
    ../HARDWARE/mpu/empl/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/NVIC/: nvic.c
  group APP
    ../APP/: main.c alarm.c alarms.c animation.c appconfig.c buttons.c diag.c display.c draw.c global.c m_display.c m_main.c menu.c millis.c watchface.c resources.c settings.c sleep.c sound.c stopwatch.c time.c timedate.c torch.c tune.c tunemaker.c tunes.c pwrmgr.c rtc.c calendar.c gui_log_console.c my_menu.c altitude_display.c
  group GAMES
    ../APP/games/: games.c game1.c game2.c game3.c game_snake.c
    ../APP/games/gamelife/: gamecontrol.c gamelife.c gametitle.c
